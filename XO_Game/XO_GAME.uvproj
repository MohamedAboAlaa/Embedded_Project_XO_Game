# Keil uVision project XO_GAME.uvproj, settings and files
target Game (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: XO_GAME
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./Drivers_Source/: Sound.c DAC.c main.c Game.c UART.c Timer.c GPIO.c ADC.c Nokia5110.c TExaS.c PLL.c
  group Header
    ./Drivers_Header/: Sound.h DAC.h UART.h Timer.h Game.h ADC.h GPIO.h GameArt.h Nokia5110.h TExaS.h tm4c123gh6pm.h PLL.h
